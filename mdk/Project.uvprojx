# Keil uVision project Project.uvprojx, settings and files
target STM32F334R8-Nucleo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F334R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F334R8-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F334x8,USE_STM32F3XX_NUCLEO
  c misc: --C99
  c include: ..\code;..\sql;..\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group code
    ../code/: stm32f3xx_it.c usart.c mian.c L610_init.c L610_TCP.c L610_Ali.c ESP8266.c
  group sql
    ../sql/: stm32f3xx_ll_gpio.c stm32f3xx_ll_rcc.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c system_stm32f3xx.c
  group stratup
    ../startup/: startup_stm32f334x8.s
software components: CMSIS:CORE 4.3.0
